# Keil uVision project ETMS.uvprojx, settings and files
target ETMS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ETMS +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\User;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\MemMang;..\FreeRTOS\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c
  group USER
    ../User/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../User/adc/: adc.c
    ../User/fonts/: fonts.c
    ../User/gpio/: gpio.c
    ../User/i2c/: i2c.c
    ../User/i2c_led/: i2c_led.c
    ../User/i2c_scan/: i2c_scan.c
    ../User/tim/: tim.c
    ../User/usart/: usart.c
    ../User/dma/: dma.c
    ../User/spi/: spi.c
    ../User/i2c_dht20/: i2c_dht20.c
    ../User/spi_w25q64/: spi_w25q64.c
    ../User/storage/: adc_storage.c
    ../User/sensor/: sensor.c
    ../User/mq/: mq.c
    ../User/alarm/: alarm.c
    ../User/wifi/: esp8266.c ringbuf.c mqtt.c
  group DOC
    ../Doc/: readme.md
  group FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
